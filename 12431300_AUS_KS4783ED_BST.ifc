Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-23T11:20:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 23 11:20:27 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\1ad053cd-0a06-4e03-94f6-5ba7aa3b7a36\4fe5bc6a-d344-497f-99c9-7719effeb3fe\ifc * Database version: 5507 * Database creation date: Tue Jan 23 11:20:26 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 23 11:20:27 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 23 11:20:27 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12431300_AUS_KS4783ED_BST:36478353_AUS_12431300_KS4783ED_BST, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 36478353_AUS_12431300_KS4783ED_BST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 36478353_AUS_12431300_KS4783ED_BST
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1850 mm; Depth: 675 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_Steel_Chrom, z_Miele_Design_BST, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass, z_Miele_Design_BRWS
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355316
Description: Flow; FlowDirection: SOURCEANDSINK
